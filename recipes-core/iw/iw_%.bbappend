FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-RX-FCS-mpdus-support.patch"
