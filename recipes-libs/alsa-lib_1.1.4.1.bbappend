PACKAGES="alsa-lib-dbg alsa-lib-staticdev alsa-lib-dev alsa-lib-doc alsa-lib-locale  alsa-lib alsa-server libasound alsa-conf alsa-doc"
FILES_${PN} += "${datadir}/*"
